<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleCIE.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleCIE</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleCIE</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleCIE</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SampleCIE</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


