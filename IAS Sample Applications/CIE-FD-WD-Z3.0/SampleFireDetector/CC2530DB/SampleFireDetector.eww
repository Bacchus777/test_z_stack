<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleFireDetector.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleFireDetector</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleFireDetector</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleFireDetector</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SampleFireDetector</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


