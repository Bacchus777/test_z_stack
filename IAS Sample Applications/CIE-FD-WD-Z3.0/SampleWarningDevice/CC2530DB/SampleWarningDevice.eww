<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleWarningDevice.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleWarningDevice</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleWarningDevice</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleWarningDevice</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SampleWarningDevice</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


